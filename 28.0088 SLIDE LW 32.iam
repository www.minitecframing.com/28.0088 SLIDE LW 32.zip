# Autodesk Inventor assembly: 28.0088 SLIDE LW 32
## iProperties
Created: 2007-06
Part Number: 28.0088 SLIDE LW 32
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
